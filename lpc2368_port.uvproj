# Keil uVision project lpc2368_port.uvproj, settings and files
target LPC2368Kit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: GPRS_OS1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __DEBUG_FLASH
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group Target
    ./app/: target.c IRQ.s Startup.s
  group ARM
    ./arm/: Os_cpu_c.c Os_cpu_a.s
  group UCOS
    ./ucosii/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group miscellaneous
    ./miscellaneous/Arithmetic/: _Arithmetic.c
    ./miscellaneous/CodeTrans/: _AscNumber.c
    ./miscellaneous/Date/: _Date.c
  group HardWare
    ./HardWare/Can/: _Can.c
    ./HardWare/RTC/: _RTC.c
    ./HardWare/Spi/: _Spi.c
    ./HardWare/UART/: _UART.C
    ./HardWare/ADC/: ADCHard.C
    ./HardWare/DS18B20/: DS18B20.c
  group Dev
    ./Dev/GPRS/Huaiwei/: HuaiweiGprs.c
    ./Dev/GPRS/: GprsHard.c
    ./Dev/Sensor/Less/: Less.c
    ./Dev/Sensor/ACC/: ACC.C
    ./Dev/Sensor/Oil/: Oil.c
    ./Dev/Sensor/: Sensor.c
    ./Dev/Sensor/Gps/: Gps.c
    ./Dev/Sensor/Display/: Display.c
    ./Dev/Sensor/temperture/: temperture.c
    ./Dev/Sensor/mileage/: mileage.c
    ./Dev/Sensor/GprsTzxy/: GprsTzxy.C
    ./Dev/Sensor/UartTzxy/: UartTzxy.C
    ./Dev/Sensor/arealrm/: arealrm.c
    ./Dev/Sensor/Help/: Help.C
    ./Dev/Sensor/OnOff/: OnOrOff.C
    ./Dev/Sensor/ADC/: Adc1.c
    ./Dev/Sensor/SmsTzxy/: SmsTzxy.C
  group File
    ./File/: _rwFile.c _DownFile.c
  group Control
    ./Control/Sensor/: SensorContr.c
    ./Control/Gprs/: GPRS.c
    ./Control/Timer/: Timer.c
    ./Control/Photo/: Photo.c
    ./Control/GpsAndMileage/: GpsAndMileage.c
    ./Control/FTP/: FTP.c
  group AgreeOn
    ./AgreeOn/TzV2.1/Agree/: Tz_Agreen.c
    ./AgreeOn/TzV2.1/Send/: Tz_Send.c
    ./AgreeOn/: TzV2.1.C
  group Flash
    ./Dev/Flash/NandFlash/512/: _NandFlash512.c
    ./Dev/Flash/SpiFlash/: _SpiFlash512.c
    ./Dev/Flash/: _Flash.c _rwflashlgc.c
  group FileData
    ./FilleData/: _FileData.c TakeData.c
  group AppSendAgreeOn
    ./AppSendAgreeOn/: AppSendAgreeOn.c
  group AppAgreeOn
    ./AppAgreenOn/: AppGprs.c
  group OpenSensor
    ./OpenSensor/: OpenSensor.c
  group AppOper
    ./AppOper/: AccOper.c Space.c JugeOper.c WarningUpate.c DisPlayOper.c MessageAndPhone.c
    ./AppSensor/: AppAgreeDataSensor.c
  group AppTask
    ./AppTask/LogOnServer/: LogOnServer.c
    ./AppTask/OpenClose/: OpenAndClose.c
    ./AppTask/UpdateSoftWare/: UpdateSoftWare.c
  group Main
    ./main/: _Init.c
